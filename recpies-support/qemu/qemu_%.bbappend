DEPENDS_append = " virglrenderer"
